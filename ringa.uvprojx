# Keil uVision project ringa.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.1
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ringa
  c flags: Optim=1 uC99=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_NRF6310 ENABLE_DEBUG_LOG_SUPPORT
  c include: .\Include;.\Include\app_common;.\Include\ble;.\Include\ble\ble_services;.\Include\ble\device_manager;.\Include\boards;.\Include\ext_sensors;.\Include\s120;.\Include\sd_common;.\Include\sdk;.\Include\app
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Applications
    ./application/: main.c
  group Services
    ./services/: ble_bas_c.c ble_hrs_c.c
  group Libraries
    ./libraries/: app_button.c app_gpiote.c app_timer.c app_trace.c ble_db_discovery.c ble_debug_assert_handler.c device_manager_central.c nrf6350.c pstorage.c simple_uart.c softdevice_handler.c twi_hw_master.c
  group ::Device
    RTE/Device/nRF51822_xxAB/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
